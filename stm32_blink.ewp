# IAR project stm32_blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.PreInclude: stm32f10x_conf.h
  ICCARM.CCIncludePath2: system; core; perlib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_blink.srec
  ILINK.IlinkOutputFile: stm32_blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    core/: core_cm3.h core_cmFunc.h core_cmInstr.h
    ./: main.c
    perlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
    perlib/inc/: misc.h stm32f10x_gpio.h stm32f10x_rcc.h
    startup/: startup_stm32f10x_md.s
    system/: stm32f10x.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
